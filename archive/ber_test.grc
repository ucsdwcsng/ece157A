options:
  parameters:
    generate_options: qt_gui
    id: ber_test
    output_language: python
    title: BER Example
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: cw_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_formatter_0
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: num_tag_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '31'
  states: {}
- name: pn5
  id: variable
  parameters:
    value: '[1,-1,1,-1,1, 1, 1, -1, 1, 1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, -1, -1]'
  states: {}
- name: pn6
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, -1 -1 -1] '
  states: {}
- name: pn6_padded
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, -1 -1 -1, 0, 0, 0, 0, 0, 0, 0, 0, 0] '
  states: {}
- name: pn_order
  id: variable
  parameters:
    value: np.round(np.log2(payload_len+1))
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: sigma
  id: variable_qtgui_range
  parameters:
    label: Std. Dev.
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.2'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sync_seq
  id: variable
  parameters:
    value: '[1, 1, -1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, -1, 1, 1, -1, -1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, -1, 1, 1, 1, -1, -1, 1, -1, -1, 1, -1, 1, -1, 1, -1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, 1, 1, 1, 1] '
  states: {}
- name: tag0
  id: variable_tag_object
  parameters:
    key: pmt.intern(len_tag_key)
    offset: '0'
    src: pmt.intern("vect_cw_src")
    value: pmt.from_long(cw_len)
  states: {}
- name: tag_delay
  id: variable_qtgui_range
  parameters:
    label: Tag Marking Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '131'
    value: '64'
  states: {}
- name: tag_s
  id: variable_tag_object
  parameters:
    key: pmt.intern(len_tag_key)
    offset: '0'
    src: pmt.intern("vect_test_src")
    value: pmt.from_long(payload_len)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: corr_tag_delay
  id: parameter
  parameters:
    hide: part
    label: Correlation Tag Delay
    short_id: c
    type: intx
    value: '131'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Plotting analysis only
    constellation: const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: tag_delay
    sps: sps
    symbols: pn6_padded
    threshold: '0.8'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: int(pn_order)
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: header_len
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_length"'
    output_symbols: 'False'
    samp_rate: '1'
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"corr_est"'
    type: complex
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.formatter()
  states: {}
- name: eb
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.5'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 1]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 1]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Bit Error Rate"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '2'
    name: Correlation Estimator
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ref_payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ref_payload
  states: {}
- name: wes_packet_tx_0
  id: wes_packet_tx
  parameters:
    cw_len: cw_len
    payload_len: payload_len
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_complex_to_mag_0, '0', iir_filter_xxx_0, '0']
- [blocks_complex_to_mag_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_max_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_throttle_0, '0', digital_header_payload_demux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_0, '0']
- [digital_glfsr_source_x_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_glfsr_source_x_0, '0', wes_packet_tx_0, '0']
- [digital_header_payload_demux_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_sub_xx_0, '0']
- [digital_packet_headerparser_b_0_0, header_data, blocks_message_debug_0, print]
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0, header_data]
- [iir_filter_xxx_0, '0', blocks_max_xx_0_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_max_xx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_1, '0', blocks_sub_xx_0, '1']
- [wes_packet_tx_0, '0', digital_corr_est_cc_0, '0']

metadata:
  file_format: 1
