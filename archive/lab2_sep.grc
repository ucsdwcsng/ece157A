options:
  parameters:
    author: wes
    generate_options: qt_gui
    id: lab2
    output_language: python
    title: Lab 2
  states: {}

blocks:
- name: N
  id: variable_qtgui_range
  parameters:
    gui_hint: 13, 1,1,1
    label: Nth Sample
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: axis
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bFilter
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 12, 0,1,1
    label: Pulse Shaping Select
    label0: Rectangular
    label1: Raised Cosine
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: bNoise
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 12, 1,1,1
    label: Waveform Select
    label0: Noise Only
    label1: Signal + Noise
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: fps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freqc
  id: variable
  parameters:
    value: '900'
  states: {}
- name: freqc_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 0,1,1
    label: Carrier (MHz)
    orient: Qt.Horizontal
    start: '70'
    step: '.01'
    stop: '6000'
    value: freqc
  states: {}
- name: gain_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 1,1,1
    label: Gain (Amp)
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: lw
  id: variable
  parameters:
    value: '2'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 1,1,1
    label: Phase Offset (Degrees)
    orient: Qt.Horizontal
    start: '-180*2'
    step: '0.1'
    stop: 180*2
    value: '0'
  states: {}
- name: roll_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 13, 0,1,1
    label: Beta (Roll-Off-Factor)
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '0.99'
    value: '0.5'
  states: {}
- name: rrc_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(4, sps, 1, roll_off, 32*sps+1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: std_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 0,1,1
    label: Noise Std. Dev
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: std_dev
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '8'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_0_1_0
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: sps
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: '-N+1024'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'gain_ '
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bNoise
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*pi*phase/360)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: N
    num_inputs: sps
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: bFilter
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 6.28/100
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 6.28/100
    max_dev: '1.5'
    nfilters: '128'
    osps: sps
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    alias: pluto
    source_code: |
      # this module will be imported in the into your flowgraph

      import sys
      import os

      # run the command to generate usb.dat
      cmd1 = 'iio_info -s | grep "usb" | awk \'{print $9}\' | awk -F[ \'{print $2}\' | awk -F] \'{print $1}\' > ~/usb.dat'
      os.system(cmd1)

      # open usb.dat and print its entries
      f = open('usb.dat','r')

      strUSB = f.readlines()                  # read all the lines from iio_info -s
      num_devices = len(strUSB)-1             # get the number of devices

      # clean-up
      f.close()                               # close file once we're done.

      # remove file
      cmd2 = 'rm ~/usb.dat'
      os.system(cmd2)


      if num_devices > 0:
          strUSB = strUSB[1:]

          for n in range(num_devices):
              strUSB[n] = strUSB[n].rstrip()  # strip the "\n" chars out

          TX = strUSB[0]
          RX = strUSB[1]

      print('TX set to Pluto: ' + TX)
      print('Rx set to Pluto: ' + RX)
      print('\n')

      #print(strUSB)                           # debug print          
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: buff_size
    cyclic: 'False'
    frequency: int(freqc_*1e6)
    samplerate: int(samp_rate*1000)
    uri: epy_module_0.TX
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: buff_size
    frequency: int(freqc_*1e6)
    gain1: '''manual'''
    manual_gain1: '32'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate*1000)
    uri: epy_module_0.RX
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_filter
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: (1,1,1,1,1,1,1,1)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    affinity: '0'
    alpha2: '0.5'
    grid: 'True'
    gui_hint: tab0@0:0,1,5,1
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style2: '1'
    type: complex
    update_time: 1/fps
    xmax: axis
    xmin: '-axis'
    ymax: axis
    ymin: '-axis'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    affinity: '0'
    average: '0.05'
    bw: samp_rate*1e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab0@0:5,0,5,1
    label1: In-Phase
    label2: Quadrature
    nconnections: '2'
    type: float
    update_time: 1/fps
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    affinity: '0'
    average: '0.05'
    bw: samp_rate*1e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab0@0:0,0,5,1
    label1: Magnitude
    type: complex
    update_time: 1/fps
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '400'
    grid: 'True'
    gui_hint: tab0@0:5,1,5,1
    size: int(1e5)
    type: float
    update_time: 1/fps
    xmax: axis
    xmin: '-axis'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color3: yellow
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@1:0,0,5,1
    nconnections: '10'
    size: 2*sps
    srate: '1'
    tr_tag: '"buffer_start"'
    type: float
    update_time: 1/fps
    width1: lw
    width10: lw
    width2: lw
    width3: lw
    width4: lw
    width5: lw
    width6: lw
    width7: lw
    width8: lw
    width9: lw
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,10,2
    label0: Spectrum/Constellation
    label1: Eye Diagram
    num_tabs: '2'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_delay_0_2, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_deinterleave_0, '0', blocks_selector_0, '0']
- [blocks_deinterleave_0, '1', blocks_selector_0, '1']
- [blocks_deinterleave_0, '2', blocks_selector_0, '2']
- [blocks_deinterleave_0, '3', blocks_selector_0, '3']
- [blocks_deinterleave_0, '4', blocks_selector_0, '4']
- [blocks_deinterleave_0, '5', blocks_selector_0, '5']
- [blocks_deinterleave_0, '6', blocks_selector_0, '6']
- [blocks_deinterleave_0, '7', blocks_selector_0, '7']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_0_0, '0', blocks_delay_0_1, '0']
- [blocks_delay_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0, '8']
- [blocks_delay_0_0_0_1, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_1, '0', qtgui_time_sink_x_0, '7']
- [blocks_delay_0_0_0_1_0, '0', qtgui_time_sink_x_0, '9']
- [blocks_delay_0_0_1, '0', blocks_delay_0_0_0_1, '0']
- [blocks_delay_0_0_1, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0_1, '0', blocks_delay_0_0_1, '0']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0_2, '0', blocks_delay_0, '0']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_selector_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_selector_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_tag_gate_0, '0', blocks_complex_to_real_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', interp_fir_filter_xxx_1, '0']
- [digital_chunks_to_symbols_xx_1, '0', interp_fir_filter_xxx_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0_0, '1']
- [interp_fir_filter_xxx_1, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_1_0, '0', blocks_multiply_const_vxx_0_0_0, '0']

metadata:
  file_format: 1
