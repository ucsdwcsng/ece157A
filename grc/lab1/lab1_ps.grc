options:
  parameters:
    author: wes
    generate_options: qt_gui
    id: lab1
    output_language: python
    title: Lab 1
  states: {}

blocks:
- name: analog_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 0,1,1
    label: Gain (Analog)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '64'
    value: '32'
  states: {}
- name: bFilter
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 13, 1,1,1
    label: Filter Select
    label0: Rectangular
    label1: Raised
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 13, 0,1,1
    label: Excess BW
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.7'
  states: {}
- name: foffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 12, 0,1,1
    label: Frequency Offset (Hz)
    min_len: '10'
    orient: Qt.Horizontal
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: fps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freqc
  id: variable
  parameters:
    value: '900'
  states: {}
- name: freqc_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 0,1,1
    label: Carrier (MHz)
    orient: Qt.Horizontal
    start: '70'
    step: '.01'
    stop: '6000'
    value: freqc
  states: {}
- name: gain_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 1,1,1
    label: Gain (Amp)
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: mod_M
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 12, 1,1,1
    label: Modulation Select
    label0: BPSK
    label1: QPSK
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 1,1,1
    label: Phase Offset (Degrees)
    orient: Qt.Horizontal
    start: '-180*2'
    step: '0.1'
    stop: 180*2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: ' ( 1.0 + mod_M)'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_  * np.exp(1j * pi / 4)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mod_M
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*pi*phase/360)
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1,-1j,1j]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: buff_size
    cyclic: 'False'
    frequency: int(freqc_*1e6)+foffset
    samplerate: int(samp_rate*1000)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: buff_size
    frequency: int(freqc_*1e6)
    gain1: '''manual'''
    manual_gain1: analog_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate*1000)
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: pulse_shape_hier_0
  id: pulse_shape_hier
  parameters:
    bFilter: bFilter
    rect_taps: (1,1,1,1,1,1,1,1)
    roll_off: excess_bw
    sps: '8'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    affinity: '0'
    alpha2: '0.5'
    grid: 'True'
    gui_hint: tab0@0:0,1,10,1
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style2: '1'
    type: complex
    update_time: 1/fps
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    affinity: '0'
    bw: samp_rate*1e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab0@0:5,0,5,1
    label1: In-Phase
    label2: Quadrature
    nconnections: '2'
    type: float
    update_time: 1/fps
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    affinity: '0'
    bw: samp_rate*1e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab0@0:0,0,5,1
    label1: Magnitude
    type: complex
    update_time: 1/fps
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab0@1:0,0,10,2
    size: '131072'
    srate: samp_rate*1000
    type: complex
    update_time: 1/fps
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,10,2
    label0: Spectrum/Constellation
    label1: Time-Series
    num_tabs: '2'
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '1']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_imag_1, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_0, '0', pulse_shape_hier_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_imag_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', analog_agc_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [pulse_shape_hier_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
