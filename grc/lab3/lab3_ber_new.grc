options:
  parameters:
    generate_options: qt_gui
    id: lab3_ber
    output_language: python
    title: Lab3 BER
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: cw_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_formatter_0
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: nfilts_pfb
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_tag_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '31'
  states: {}
- name: pfb_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts_pfb, nfilts_pfb*sps, 1, rolloff, nfilts_pfb*11*sps+1)
  states: {}
- name: pi
  id: variable
  parameters:
    value: np.pi
  states: {}
- name: pn5
  id: variable
  parameters:
    value: '[1,-1,1,-1,1, 1, 1, -1, 1, 1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, -1, -1]'
  states: {}
- name: pn6
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, -1 -1 -1] '
  states: {}
- name: pn6_padded
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, -1 -1 -1, 0, 0, 0, 0, 0, 0, 0, 0, 0] '
  states: {}
- name: pn_order
  id: variable
  parameters:
    value: np.round(np.log2(payload_len+1))
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rrc_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(4, sps, 1, rolloff, 32*sps+1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '20'
    value: snr_default
  states: {}
- name: snr_default
  id: variable
  parameters:
    value: '8.5'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sync_seq
  id: variable
  parameters:
    value: '[1, 1, -1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, -1, 1, 1, -1, -1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, -1, 1, 1, 1, -1, -1, 1, -1, -1, 1, -1, 1, -1, 1, -1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, 1, 1, 1, 1] '
  states: {}
- name: tag0
  id: variable_tag_object
  parameters:
    key: pmt.intern(len_tag_key)
    offset: '0'
    src: pmt.intern("vect_cw_src")
    value: pmt.from_long(cw_len)
  states: {}
- name: tag_delay
  id: variable_qtgui_range
  parameters:
    label: Tag Marking Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '131'
    value: '64'
  states: {state: disabled}
- name: tag_s
  id: variable_tag_object
  parameters:
    key: pmt.intern(len_tag_key)
    offset: '0'
    src: pmt.intern("vect_test_src")
    value: pmt.from_long(payload_len)
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    label: Reset BER
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(2)*np.sqrt(0.5 / np.power(10,snr_db/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: calc_ber_0
  id: calc_ber
  parameters: {}
  states: {}
- name: corr_tag_delay
  id: parameter
  parameters:
    hide: part
    label: Correlation Tag Delay
    short_id: c
    type: intx
    value: '131'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Plotting analysis only
    constellation: const
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Plotting analysis only
    constellation: const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '64'
    sps: '1'
    symbols: pn6_padded
    threshold: '0.8'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*pi/200
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: int(pn_order)
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: header_len
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_length"'
    output_symbols: 'False'
    samp_rate: '1'
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"corr_est"'
    type: complex
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.formatter()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts_pfb
    init_phase: int(nfilts_pfb/2)
    loop_bw: 2*pi/200
    max_dev: '0.5'
    osps: '1'
    sps: sps
    taps: pfb_filter
    type: ccf
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import sys
      import os

      # run the command to generate usb.dat
      cmd1 = 'iio_info -s | grep "usb" | awk \'{print $9}\' | awk -F[ \'{print $2}\' | awk -F] \'{print $1}\' > usb.dat'
      os.system(cmd1)

      # open usb.dat and print its entries
      f = open('usb.dat','r')

      strUSB = f.readlines()                  # read all the lines from iio_info -s
      num_devices = len(strUSB)-1             # get the number of devices

      # clean-up
      f.close()                               # close file once we're done.

      # remove file
      cmd2 = 'rm usb.dat'
      os.system(cmd2)


      if num_devices > 0:
          strUSB = strUSB[1:]

          for n in range(num_devices):
              strUSB[n] = strUSB[n].rstrip()  # strip the "\n" chars out

          TX = strUSB[0]
          RX = strUSB[1]

          print('TX set to Pluto: ' + TX)
          print('Rx set to Pluto: ' + RX)
      else:
          print('No Devices Found!')

      print('\n')

      #print(strUSB)                           # debug print          
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(900e6)
    samplerate: int(samp_rate*1e3)
    uri: epy_module_0.TX
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(900e6)
    gain1: '''manual'''
    manual_gain1: '36'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate*1e3)
    uri: epy_module_0.RX
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pulse_shape_hier_0
  id: pulse_shape_hier
  parameters:
    bFilter: '1'
    roll_off: rolloff
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.5'
    grid: 'True'
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style2: '1'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Bit Error Rate"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: 1e6
    min: '0'
    name: '"# of Errors"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ref_payload
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: header_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ref_payload
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: header_in
  states: {}
- name: wes_packet_tx_0
  id: wes_packet_tx
  parameters:
    cw_len: cw_len
    payload_len: payload_len
    samp_rate: samp_rate
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '1']
- [calc_ber_0, '0', qtgui_number_sink_0, '0']
- [calc_ber_0, '1', qtgui_number_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', calc_ber_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_add_xx_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', calc_ber_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [digital_glfsr_source_x_0, '0', virtual_sink_1, '0']
- [digital_glfsr_source_x_0, '0', wes_packet_tx_0, '0']
- [digital_header_payload_demux_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [digital_header_payload_demux_0, '1', digital_constellation_decoder_cb_0_0_0_0_0, '0']
- [digital_packet_headerparser_b_0_0, header_data, blocks_message_debug_0, print]
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_pfb_clock_sync_xxx_0, '0', digital_corr_est_cc_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [pulse_shape_hier_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_0, '0', virtual_sink_2, '0']
- [virtual_source_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_2, '0', digital_header_payload_demux_0, '0']
- [wes_packet_tx_0, '0', pulse_shape_hier_0, '0']

metadata:
  file_format: 1
