options:
  parameters:
    author: wes
    generate_options: qt_gui
    id: lab3
    output_language: python
    title: Lab 3
  states: {}

blocks:
- name: axis
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bSelectPLL
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 12, 1,1,1
    label: PLL Order
    label0: Standard
    label1: Costas
    label2: Costas w/ HL
    label3: QPSK Costas
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: bSignal
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 12, 0,1,1
    label: Signal Select
    label0: Tone
    label1: BPSK
    label2: QPSK
    num_opts: '3'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: const_qpsk
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: fo
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 1,1,1
    label: Frequency Offset (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: 100e3
    value: '0'
  states: {}
- name: fps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freqc
  id: variable
  parameters:
    value: '900'
  states: {}
- name: freqc_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 0,1,1
    label: Carrier (MHz)
    orient: Qt.Horizontal
    start: '70'
    step: '.01'
    stop: '6000'
    value: freqc
  states: {}
- name: gain_
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 1,1,1
    label: Gain (Amp)
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: lw
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nat_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 13, 1,1,1
    label: Natural Freq (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 100e3
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: std_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 11, 0,1,1
    label: Noise Std. Dev
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: zeta
  id: variable_qtgui_range
  parameters:
    gui_hint: 13, 0,1,1
    label: Damping Factor (Zeta)
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '4'
    value: '0.707'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: std_dev
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*1000
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'gain_ '
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/6.28*samp_rate*1000
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: bSignal
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_bpsk.points()
  states: {}
- name: digital_chunks_to_symbols_xx_1_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_qpsk.points()
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import sys
      import os

      # run the command to generate usb.dat
      cmd1 = 'iio_info -s | grep "usb" | awk \'{print $9}\' | awk -F[ \'{print $2}\' | awk -F] \'{print $1}\' > usb.dat'
      os.system(cmd1)

      # open usb.dat and print its entries
      f = open('usb.dat','r')

      strUSB = f.readlines()                  # read all the lines from iio_info -s
      num_devices = len(strUSB)-1             # get the number of devices

      # clean-up
      f.close()                               # close file once we're done.

      # remove file
      cmd2 = 'rm usb.dat'
      os.system(cmd2)


      if num_devices > 0:
          strUSB = strUSB[1:]

          for n in range(num_devices):
              strUSB[n] = strUSB[n].rstrip()  # strip the "\n" chars out

          TX = strUSB[0]
          RX = strUSB[1]

          print('TX set to Pluto: ' + TX)
          print('Rx set to Pluto: ' + RX)
      else:
          print('No Devices Found!')

      print('\n')

      #print(strUSB)                           # debug print          
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: buff_size
    cyclic: 'False'
    frequency: int(freqc_*1e6)
    samplerate: int(samp_rate*1000)
    uri: epy_module_0.TX
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: buff_size
    frequency: int(freqc_*1e6)
    gain1: '''manual'''
    manual_gain1: '32'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate*1000)
    uri: epy_module_0.RX
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: (1,1,1,1,1,1,1,1)
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: (1,1,1,1,1,1,1,1)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    affinity: '0'
    bw: samp_rate*1e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab0@1:5,0,5,1
    label1: In-Phase
    type: complex
    update_time: 1/fps
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@0:5,0,5,1
    size: '4096'
    srate: samp_rate*1000
    type: complex
    ylabel: Frequency (Hz)
    ymax: '10000'
    ymin: '-10000'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,10,2
    label0: Loop Filter Output
    label1: Spectrum
    num_tabs: '2'
  states: {}
- name: wes_costas_cc_0
  id: wes_costas_cc
  parameters:
    fn: nat_freq / (samp_rate*1000)
    loop_type: bSelectPLL
    zeta: zeta
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', wes_costas_cc_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_selector_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_add_xx_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_2, '0']
- [digital_chunks_to_symbols_xx_1, '0', interp_fir_filter_xxx_1_0, '0']
- [digital_chunks_to_symbols_xx_1_0, '0', interp_fir_filter_xxx_1_0_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [interp_fir_filter_xxx_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [interp_fir_filter_xxx_1_0, '0', blocks_selector_0_0, '1']
- [interp_fir_filter_xxx_1_0_0, '0', blocks_selector_0_0, '2']
- [wes_costas_cc_0, '0', blocks_null_sink_0, '0']
- [wes_costas_cc_0, '1', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
