options:
  parameters:
    category: Custom
    description: Pluto FFT Waveform Plotter
    generate_options: qt_gui
    id: pluto_fft
    output_language: python
    title: Pluto FFT
  states: {}

blocks:
- name: freq_c
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,2
    label: Carrier Frequency (MHz)
    type: real
    value: freq
  states: {}
- name: gain_
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: gain
  states: {}
- name: rf_bandwidth_
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,3,1,1
    label: Passband Bandwidth (kHz)
    type: real
    value: rf_bandwidth
  states: {}
- name: samp_rate_
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,2,1,1
    label: Sampler Rate (kHz)
    type: real
    value: samp_rate
  states: {}
- name: display
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: Spectrum
    label1: Waterfall
    label2: Scope
    num_tabs: '3'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: Set number of FFT bins
    type: intx
    value: '1024'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency (MHz)
    short_id: f
    type: eng_float
    value: '89.5'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Set gain in dB (default is midpoint)
    short_id: g
    type: eng_float
    value: '32'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(rf_bandwidth_*1000)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freq_c*1e6)
    gain1: '''manual'''
    manual_gain1: gain_
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate_*1000)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate_*1000
    ctrlpanel: 'True'
    fc: freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: display@0:0,0,1,4
    legend: 'False'
    name: ''
    type: complex
    update_time: update_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: display@2:0,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: ''
    size: '1024'
    srate: samp_rate_*1000
    type: complex
    update_time: update_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_*1000
    fc: freq
    fftsize: '1024'
    gui_hint: display@1:0,0,1,4
    name: ''
    showports: 'True'
    type: complex
    update_time: update_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth
    short_id: r
    type: eng_float
    value: '20000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: '1000'
  states: {}
- name: update_rate
  id: parameter
  parameters:
    label: Set GUI widget update rate
    type: eng_float
    value: '.03'
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
