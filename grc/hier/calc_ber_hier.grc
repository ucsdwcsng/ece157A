options:
  parameters:
    author: wes
    category: WES Blocks
    generate_options: hb
    id: calc_ber
    output_language: python
    title: BER Computation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 1]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 1]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: BER Estimate
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: '# of Errors'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: payload in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ref in
    type: complex
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_complex_to_mag_0, '0', iir_filter_xxx_0, '0']
- [blocks_complex_to_mag_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_divide_xx_0, '0', pad_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_max_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_max_xx_0_0, '0', pad_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [iir_filter_xxx_0, '0', blocks_max_xx_0_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_max_xx_0, '0']
- [pad_source_0, '0', blocks_sub_xx_0, '0']
- [pad_source_1, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
