options:
  parameters:
    category: WES Blocks
    generate_options: hb
    id: pulse_shape_hier
    output_language: python
    title: Pulse Shaping Block (Hier)
  states: {}

blocks:
- name: rrc_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(4, sps, 1, roll_off, 32*sps+1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bFilter
  id: parameter
  parameters:
    label: Filter Select
    value: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: bFilter
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_filter
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_filter
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rect_taps
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rect_taps
  id: parameter
  parameters:
    label: Filter
    value: (1,1,1,1,1,1,1,1)
  states: {}
- name: roll_off
  id: parameter
  parameters:
    label: Beta (Roll-Off)
    value: '0.7'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples Per Symbol
    value: '4'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_selector_0_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0_0, '1']
- [interp_fir_filter_xxx_1, '0', blocks_selector_0_0, '2']
- [interp_fir_filter_xxx_1, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_1_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [pad_source_0, '0', interp_fir_filter_xxx_1, '0']
- [pad_source_0, '0', interp_fir_filter_xxx_1_0, '0']

metadata:
  file_format: 1
