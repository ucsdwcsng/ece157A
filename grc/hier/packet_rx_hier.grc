options:
  parameters:
    category: WES Packet
    generate_options: hb
    id: wes_packet_rx
    output_language: python
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,2)
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: modulated_preamble
  id: variable_modulate_vector
  parameters:
    data: preamble_hex
    mod: preamble_modulator
    taps: '[1]'
  states: {}
- name: nfilts_pfb
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_tag_key
  id: variable
  parameters:
    value: '"bits_per_byte"'
  states: {}
- name: pfb_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts_pfb, nfilts_pfb*samp_symb, 1, rolloff, nfilts_pfb*11*samp_symb+1)
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592654'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_bit[0:64]
  states: {}
- name: preamble_bit
  id: variable
  parameters:
    value: '[1,1,1,0,1,0,1,1,0,0,0,1,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,1,0,0,1,1,0,1,1,0,1,1,0,0,0,1,1,0,1,0,1,0,0,0,1,0,1,0,0,1,0,0,1,1,1,1,1,1,1,0,0,1,1,0,0,0,0,0,1,1,0,1,0,0,1,0,0,0,1,1,1,0,0,0,0,1,0,0,1,1,0,0,1,1,1,0,1,1,1,1,1,1,0,1,1,1,0,0,0,0,1,1,0,1,0,0,0,1,0,0,0,1]'
  states: {}
- name: preamble_hex
  id: variable
  parameters:
    value: '[0xEB, 0x11, 0x9C, 0x33, 0x6C, 0x6A, 0x29, 0x3F, 0x98, 0x34, 0x8E, 0x13, 0x3B, 0xF7, 0x0D, 0x11]'
  states: {}
- name: preamble_modulator
  id: variable
  parameters:
    value: digital.generic_mod(const, False, samp_symb, False, rolloff, False, False)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_symb
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sliced_modulated_preamble
  id: variable
  parameters:
    value: modulated_preamble[100:]
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '8'
    len_tag_key: '"packet_length"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '2'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: num_skip
    type: byte
  states: {state: disabled}
- name: corr_tag_delay
  id: parameter
  parameters:
    hide: part
    label: Correlation Tag Delay
    short_id: c
    type: intx
    value: '131'
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Plotting analysis only
    constellation: const
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Plotting analysis only
    constellation: const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*pi/200
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_header_payload_demux_0_0
  id: digital_header_payload_demux
  parameters:
    header_len: header_len
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_length"'
    output_symbols: 'True'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"corr_est"'
    type: complex
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts_pfb
    init_phase: int(nfilts_pfb/2)
    loop_bw: 2*pi/200
    max_dev: '0.5'
    osps: '1'
    sps: samp_symb
    taps: pfb_filter
    type: ccf
  states: {}
- name: header_len
  id: parameter
  parameters:
    label: Header Length
    type: intx
    value: '32'
  states: {}
- name: num_skip
  id: parameter
  parameters:
    label: Number of Skipped Items
    type: intx
    value: '8'
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: File Out Sink
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: payload_out
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: header_out
    optional: 'True'
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: USRP_in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 1e6
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: lms_dd_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: lms_dd_out
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_null_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', pad_sink_2, '0']
- [blocks_repack_bits_bb_1, '0', digital_diff_decoder_bb_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_skiphead_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_skiphead_0, '0', pad_sink_3, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_descrambler_bb_0, '0', blocks_skiphead_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_diff_decoder_bb_0, '0', pad_sink_3_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_skiphead_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_descrambler_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', pad_sink_3, '0']
- [digital_header_payload_demux_0_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [digital_header_payload_demux_0_0, '1', digital_constellation_decoder_cb_0_0_0_0_0, '0']
- [digital_packet_headerparser_b_0_0, header_data, blocks_message_debug_0, print]
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0_0, header_data]
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [pad_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', digital_header_payload_demux_0_0, '0']

metadata:
  file_format: 1
