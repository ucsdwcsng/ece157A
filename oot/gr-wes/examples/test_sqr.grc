options:
  parameters:
    author: wes
    generate_options: qt_gui
    id: test_square
    output_language: python
    title: test the square block
  states: {}

blocks:
- name: amp_
  id: variable_qtgui_range
  parameters:
    label: Gain (amp)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: fps
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: 1/fps
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: 1/fps
  states: {}
- name: wes_square_ff_1
  id: wes_square_ff
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', wes_square_ff_1, '0']
- [wes_square_ff_1, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
